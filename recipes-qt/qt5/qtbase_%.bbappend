PACKAGECONFIG_append = " accessibility eglfs fontconfig gles2 linuxfb tslib"
PACKAGECONFIG_remove = "examples tests x11 webkit qtwebkit-dev webkit-dev"

DEPENDS += "userland"

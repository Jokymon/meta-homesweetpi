PACKAGECONFIG_remove = "qtwebkit"
